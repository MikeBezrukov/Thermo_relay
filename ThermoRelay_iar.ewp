# IAR project ThermoRelay_iar.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgtiny24.xcl
  XLINK.XExtraOptions: -Ointel-standard,(CODE)=.code.hex; -Ointel-standard,(XDATA)=.eeprom.hex
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
  group (top)
    ./: avr_compiler.h bcd.h bcd.s90 buttons.c buttons.h customization.h display.c display.h ds18b20.c ds18b20.h init.c main.c operation.c operation.h relay.c relay.h to.c to.h usi.c usi.h voltagectrl.c voltagectrl.h
